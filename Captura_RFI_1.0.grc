options:
  parameters:
    author: Daniel Gomez
    generate_options: qt_gui
    id: Captura_RFI
    output_language: python
    title: Captura RFI
  states: {}

blocks:
- name: Intervalo_Tiempo
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: frec_final
  id: variable
  parameters:
    value: '300000000'
  states: {}
- name: frec_inicial
  id: variable
  parameters:
    value: '80000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: CSV
  id: epy_block
  parameters:
    Filename_csv: '"CSV_Salida"'
    _source_code: "import os\r\nimport csv\r\nimport numpy as np\r\nfrom gnuradio import gr\r\nimport pmt\r\nfrom datetime import datetime\r\n\r\nclass CSVWriterBlock(gr.sync_block):\r\n\r\n    def __init__(self, Filename_csv=\"CSV_Salida\"):\r\n        gr.sync_block.__init__(\r\n            self,\r\n            name=\"CSV Writer Block\",\r\n            in_sig=[(np.float32, 1024)],  # Tipo de datos de entrada (float32) y tamaño de bloque (1024)\r\n            out_sig=None,\r\n        )\r\n\r\n        # Define la direccion donde se guarda el csv\r\n        output_dir = \"Salida\"\r\n        if not os.path.exists(output_dir):\r\n            os.makedirs(output_dir)\r\n\r\n        # Genera dia-mes-año_hora-min-s para el nombre del archivo csv\r\n        now = datetime.now()\r\n        date_time_str = now.strftime(\"%d-%m-%Y_%H-%M-%S\")\r\n\r\n        # Construye el nombre del archivo\r\n        filename = f\"{Filename_csv}_{date_time_str}.csv\"\r\n        self.filename = os.path.join(output_dir, filename)\r\n        print(f\"-- Medición guardada en: {self.filename} --\")  \r\n\r\n        self.file = open(self.filename, \"w\", newline=\"\")\r\n        self.writer = csv.writer(self.file)\r\n        self.prev_freq_value = None  # Valor de frecuencia anterior\r\n        self.header_written = False  # Variable para rastrear si se ha escrito el encabezado\r\n\r\n        # Registrar la entrada de mensajes\r\n        self.message_port_register_in(pmt.intern(\"Frec_in\"))\r\n        self.set_msg_handler(pmt.intern(\"Frec_in\"), self.handle_message)\r\n\r\n    def handle_message(self, msg):\r\n        # Procesar el mensaje asíncrono y almacenar los datos numéricos\r\n        message_data = pmt.to_python(msg)\r\n        freq_value = message_data.get('freq', None)\r\n\r\n        if freq_value is not None:\r\n            freq_value = float(freq_value)  # Convertir a float\r\n            if self.prev_freq_value is None or freq_value != self.prev_freq_value:\r\n                self.prev_freq_value = freq_value\r\n                print(\"Valor numérico de frecuencia:\", freq_value)\r\n\r\n    def work(self, input_items, output_items):\r\n        data_array = input_items[0]\r\n\r\n        # Verificar si se ha escrito el encabezado y escribirlo si no\r\n        if not self.header_written:\r\n            self.writer.writerow([\"Frecuencia (Hz)\", \"dB\"])\r\n            self.header_written = True\r\n\r\n        # Verificar si hay un mensaje y obtener el valor de frecuencia si existe\r\n        freq_value = None\r\n        if hasattr(self, 'prev_freq_value'):\r\n            freq_value = self.prev_freq_value\r\n\r\n        # Utilizar NumPy para organizar los datos en filas\r\n        data_array = data_array.reshape(-1, 1)\r\n\r\n        # Crear una columna de valores de frecuencia\r\n        if freq_value is not None:\r\n            freq_column = np.full((len(data_array), 1), freq_value, dtype=np.float32)\r\n        else:\r\n            freq_column = np.full((len(data_array), 1), np.nan, dtype=np.float32)  # Si no hay frecuencia, llenar con NaN\r\n\r\n        # Combinar los valores de frecuencia y los datos en una sola matriz\r\n        combined_data = np.hstack((freq_column, data_array))\r\n\r\n        # Escribir los datos combinados en el archivo CSV\r\n        self.writer.writerows(combined_data.tolist())\r\n\r\n        # Devolver el número de elementos procesados\r\n        return len(input_items[0])\r\n\r\n    def stop(self):\r\n        # Cerrar el archivo CSV cuando se detenga el flujo\r\n        self.file.close()\r\n"
  states: {}
- name: Control_Frecuencia
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import time
      import pmt

      class blk(gr.sync_block):
          """sending asynchronous messages"""

          def __init__(self, frec_inicial=100000000, frec_final=200000000, intervalo_tiempo=5, ancho_banda=20000000):
              
              gr.sync_block.__init__(
                  self,
                  name='Control frecuencia USRP',
                  in_sig=None,  # No input signal
                  out_sig=None  # No output signal
              )

              # DECLARA LAS VARIABLES INICIALES ||||| Frec_I1 = frec_ini + BW/2 ,  Frec_I2 = Frec_I1 + BW ..... Frec_Fn = Frec_In-1 + BW/2 || if (Frec_Fn == frec_final) = Frec_Fn = Frec_I1

              self.Val_frec = True

              self.frec_inicial = (frec_inicial) + (ancho_banda/2)
              self.frec_final = frec_final
              self.intervalo_tiempo = intervalo_tiempo
              self.intervalo_cambio = ancho_banda
              self.frec_cambio = (frec_inicial) + (ancho_banda/2)

              # Configurar el puerto de mensajes
              self.message_port_register_out(pmt.intern("Frec_out"))

              # Iniciar el hilo del remitente del mensaje
              self.msg_thread = MsgSenderThread(self)
              self.msg_thread.start()



          def send_message(self):

              if self.Val_frec:                      
                  self.frec_cambio = self.frec_inicial
                  self.Val_frec = False

              # Crear el diccionario freq_msg
              freq_msg = {'freq': self.frec_inicial}

              # Enviar freq_msg como un mensaje asincrónico
              msg = pmt.to_pmt(freq_msg)
              self.message_port_pub(pmt.intern("Frec_out"), msg)

              # Calcula el nuevo valor de frecuencia
              self.frec_inicial += self.intervalo_cambio       

              # Si la frecuencia supera el valor final, vuelve a iniciar desde el valor inicial
              if (self.frec_inicial) >= (self.frec_final):
                  self.frec_inicial = self.frec_cambio
                  self.Val_frec = True

          def stop(self):
              self.msg_thread.stop()
              self.msg_thread = None

          def msg_handler(self, msg):
              if pmt.is_eq(msg, pmt.intern("msg_send")):
                  self.send_message()

      class MsgSenderThread(gr.threading.Thread):
          def __init__(self, block):
              gr.threading.Thread.__init__(self)
              self.block = block
              self.running = True

          def stop(self):
              self.running = False

          def run(self):
              while self.running:
                  time.sleep(self.block.intervalo_tiempo)
                  self.block.send_message()
    ancho_banda: samp_rate
    frec_final: frec_final
    frec_inicial: frec_inicial
    intervalo_tiempo: Intervalo_Tiempo
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: '1024'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: '0.000976562'
    type: complex
    vlen: '1024'
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: '1024'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '1024'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: '50000'
    type: float
    vlen: '1024'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '1024'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(1024)
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    vlen: '1024'
    x_axis_label: '"Frecuencia MHz"'
    x_start: '0'
    x_step: '1.0'
    y_axis_label: '"dB"'
    ymax: '2'
  states: {}
- name: uhd_usrp_source_1
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: '0'
    dev_args: '""'
    gain0: '1'
    gain_type0: normalized
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [Control_Frecuencia, Frec_out, CSV, Frec_in]
- [Control_Frecuencia, Frec_out, blocks_message_debug_0, print]
- [Control_Frecuencia, Frec_out, uhd_usrp_source_1, command]
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_throttle2_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_throttle2_0, '0', CSV, '0']
- [blocks_throttle2_0, '0', qtgui_vector_sink_f_0, '0']
- [fft_vxx_0, '0', blocks_multiply_const_xx_0, '0']
- [uhd_usrp_source_1, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
