options:
  parameters:
    author: Daniel Gomez
    generate_options: qt_gui
    id: Captura_RFI
    output_language: python
    title: Captura RFI
  states: {}

blocks:
- name: frec_final
  id: variable
  parameters:
    value: '200000000'
  states: {}
- name: frec_inicial
  id: variable
  parameters:
    value: '80000000'
  states: {}
- name: frec_inicial
  id: variable_qtgui_range
  parameters:
    label: frec_inicial
    orient: Qt.Horizontal
    start: '80000000'
    step: '10000000'
    stop: '200000000'
    value: '80000000'
  states: {state: disabled}
- name: frec_total
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: '1024'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\dfgom\OneDrive\Escritorio\USRP\RFI_Captura\Salida\Dat_crudos
    type: float
    vlen: '1024'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: '0.000976562'
    type: complex
    vlen: '1024'
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: '1024'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '1024'
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "###################################################################################################\r\n\r\n# import numpy as np\r\n# import csv\r\n# from gnuradio import gr\r\n\r\n# class CSVWriterBlock(gr.sync_block):\r\n#     def __init__(self, filename=\"output.csv\"):\r\n#         gr.sync_block.__init__(\r\n#             self,\r\n#             name=\"CSV Writer Block\",\r\n#             in_sig=[(np.float32, 1024)],  # Tipo de datos de entrada (float) y tamaño de bloque (1024)\r\n#             out_sig=None,\r\n#         )\r\n#         self.filename = filename\r\n#         self.file = open(self.filename, \"w\", newline=\"\")\r\n#         self.writer = csv.writer(self.file)\r\n#         self.writer.writerow([\"Sample\"])\r\n\r\n#     def work(self, input_items, output_items):\r\n#         data_array = input_items[0]\r\n        \r\n#         # Escribir los datos en el archivo CSV\r\n#         self.writer.writerows(data_array)\r\n        \r\n#         # Devolver el número de elementos procesados\r\n#         return len(input_items[0])\r\n\r\n#     def stop(self):\r\n#         # Cerrar el archivo CSV cuando se detenga el flujo\r\n#         self.file.close()\r\n\r\n###################################################################################################\r\n\r\n# class CSVWriterBlock(gr.sync_block):\r\n#     def __init__(self, filename=\"output.csv\"):\r\n#         gr.sync_block.__init__(\r\n#             self,\r\n#             name=\"CSV Writer Block\",\r\n#             in_sig=[(np.float32, 1024)],  # Tipo de datos de entrada (float) y tamaño de bloque (1024)\r\n#             out_sig=None,\r\n#         )\r\n#         self.filename = filename\r\n#         self.file = open(self.filename, \"w\", newline=\"\")\r\n#         self.writer = csv.writer(self.file)\r\n\r\n#     def work(self, input_items, output_items):\r\n#         data_array = input_items[0]\r\n\r\n#         # Utilizar NumPy para organizar los datos en filas\r\n#         data_array = data_array.reshape(-1, 1)\r\n        \r\n#         # Escribir los datos en el archivo CSV\r\n#         self.writer.writerows(data_array.tolist())\r\n        \r\n#         # Devolver el número de elementos procesados\r\n#         return len(input_items[0])\r\n\r\n#     def stop(self):\r\n#         # Cerrar el archivo CSV cuando se detenga el flujo\r\n#         self.file.close()\r\n\r\n###################################################################################################\r\n\r\n# import csv\r\n# import numpy as np\r\n# from gnuradio import gr\r\n# import time\r\n# import pmt\r\n\r\n# class CSVWriterBlock(gr.sync_block):\r\n    \r\n#     def __init__(self, filename=\"output.csv\"):\r\n#         gr.sync_block.__init__(\r\n#             self,\r\n#             name=\"CSV Writer Block\",\r\n#             in_sig=[(np.float32, 1024)],  # Tipo de datos de entrada (float) y tamaño de bloque (1024)\r\n#             out_sig=None,\r\n#         )\r\n#         self.filename = filename\r\n#         self.file = open(self.filename, \"w\", newline=\"\")\r\n#         self.writer = csv.writer(self.file)\r\n        \r\n#         # Registrar la entrada de mensajes\r\n#         self.message_port_register_in(pmt.intern(\"Frec_in\"))\r\n#         self.set_msg_handler(pmt.intern(\"Frec_in\"), self.handle_message)\r\n\r\n#     def handle_message(self, msg):\r\n#         # Procesar el mensaje asíncrono y almacenar los datos en la variable \r\n#         self.message_data = pmt.to_python(msg)\r\n#         print(\"Mensaje recibido:\", self.message_data)\r\n\r\n\r\n#     def work(self, input_items, output_items):\r\n#         data_array = input_items[0]\r\n\r\n#         # Verificar si hay un mensaje y procesarlo si existe\r\n#         if hasattr(self, 'message_data'):\r\n#             #print(\"Mensaje almacenado en handle_message:\", self.message_data)\r\n   \r\n#             freq_value = self.message_data.get('freq', None)\r\n#             if freq_value is not None:\r\n#                 print(\"Valor numérico de frecuencia:\", freq_value)\r\n\r\n#             self.Frec_central = self.message_data\r\n\r\n#         # Utilizar NumPy para organizar los datos en filas\r\n#         data_array = data_array.reshape(-1, 1)\r\n\r\n#         # Escribir los datos en el archivo CSV\r\n#         self.writer.writerows(data_array.tolist())\r\n\r\n#         # Devolver el número de elementos procesados\r\n#         return len(input_items[0])\r\n\r\n#     def stop(self):\r\n#         # Cerrar el archivo CSV cuando se detenga el flujo\r\n#         self.file.close()\r\n\r\n####################################### prueba con cambio a valor flotante y que solo imprima si cambia ################# falta añadir lo de las frecuencias que estan en el otro codigo y cambiarlo a la otra columna \r\nimport csv\r\nimport numpy as np\r\nfrom gnuradio import gr\r\nimport pmt\r\n\r\nclass CSVWriterBlock(gr.sync_block):\r\n    \r\n    def __init__(self, filename=\"output.csv\"):\r\n        gr.sync_block.__init__(\r\n            self,\r\n            name=\"CSV Writer Block\",\r\n            in_sig=[(np.float32, 1024)],  # Tipo de datos de entrada (float) y tamaño de bloque (1024)\r\n            out_sig=None,\r\n        )\r\n        self.filename = filename\r\n        self.file = open(self.filename, \"w\", newline=\"\")\r\n        self.writer = csv.writer(self.file)\r\n        self.prev_freq_value = None  # Valor de frecuencia anterior\r\n\r\n        # Registrar la entrada de mensajes\r\n        self.message_port_register_in(pmt.intern(\"Frec_in\"))\r\n        self.set_msg_handler(pmt.intern(\"Frec_in\"), self.handle_message)\r\n\r\n    def handle_message(self, msg):\r\n        # Procesar el mensaje asíncrono y almacenar los datos numéricos\r\n        message_data = pmt.to_python(msg)\r\n        freq_value = message_data.get('freq', None)\r\n\r\n        if freq_value is not None:\r\n            freq_value = float(freq_value)  # Convertir a float\r\n            if self.prev_freq_value is None or freq_value != self.prev_freq_value:\r\n                self.prev_freq_value = freq_value\r\n                print(\"Valor numérico de frecuencia:\", freq_value)\r\n\r\n    def work(self, input_items, output_items):\r\n        data_array = input_items[0]\r\n\r\n        # Utilizar NumPy para organizar los datos en filas\r\n        data_array = data_array.reshape(-1, 1)\r\n\r\n        # Escribir los datos en el archivo CSV\r\n        self.writer.writerows(data_array.tolist())\r\n\r\n        # Devolver el número de elementos procesados\r\n        return len(input_items[0])\r\n\r\n    def stop(self):\r\n        # Cerrar el archivo CSV cuando se detenga el flujo\r\n        self.file.close()\r\n"
    filename: r"C:\Users\dfgom\OneDrive\Escritorio\USRP\RFI_Captura\Salida\outputprueba2.csv"
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import csv
      import matplotlib.pyplot as plt

      class CSVWriterAndPlotBlock(gr.sync_block):

          def __init__(self, filename="output.csv", central_frequency=115000000, bandwidth=170000000, image_filename="data_plot.png"):

              gr.sync_block.__init__(
                  self,
                  name="CSV Writer and Plot Block",
                  in_sig=[(np.float32, 1024)],
                  out_sig=None,
              )
              self.filename = filename
              self.central_frequency = central_frequency
              self.bandwidth = bandwidth
              self.save_image = True
              self.image_filename = image_filename
              self.file = open(self.filename, "w", newline="")
              self.first_work_call = True
              self.writer = None
              self.fig, self.ax = plt.subplots()

          def work(self, input_items, output_items):
              """Write data to the CSV file and plot the data"""
              if self.first_work_call:
                  self.writer = csv.writer(self.file)
                  self.writer.writerow(["Frequency (Hz)", "dBs"])  # Write the header to the CSV file
                  self.first_work_call = False

              data_array = input_items[0]

              data_array_transposed = np.transpose(data_array)

              num_samples = data_array_transposed.shape[0]
              frequencies = np.linspace(
                  self.central_frequency - self.bandwidth / 2,
                  self.central_frequency + self.bandwidth / 2,
                  num_samples
              )

              data_with_freq = np.column_stack((frequencies, data_array_transposed))

              # Write CSV file
              self.writer.writerows(data_with_freq)

              frequencies_plot = data_with_freq[:, 0]
              data_plot = data_with_freq[:, 1]

              # Plot the data
              self.ax.clear()
              self.ax.plot(frequencies_plot, data_plot)
              self.ax.set_xlabel("Frequency (Hz)")
              self.ax.set_ylabel("dBs")
              self.ax.set_title("RFI")
              self.ax.grid(False)

              if self.save_image:
                  plt.savefig(self.image_filename)

              return len(input_items[0])

          def stop(self):
              """Stop the block and close the CSV file"""
              self.file.close()
              #plt.show()  # Display the plot after processing is done
    bandwidth: samp_rate_0
    central_frequency: '115000000'
    filename: r"C:\Users\dfgom\OneDrive\Escritorio\USRP\RFI_Captura\Salida\Salidapp.csv"
    image_filename: r"C:\Users\dfgom\OneDrive\Escritorio\USRP\RFI_Captura\Salida\OutputPLOT.png"
  states: {state: disabled}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import time
      import pmt

      class blk(gr.sync_block):
          """sending asynchronous messages"""

          def __init__(self, frec_inicial=100000000, frec_final=200000000, intervalo_tiempo=5, ancho_banda=20000000):
              
              gr.sync_block.__init__(
                  self,
                  name='Control frecuencia USRP',
                  in_sig=None,  # No input signal
                  out_sig=None  # No output signal
              )

              # DECLARA LAS VARIABLES INICIALES ||||| Frec_I1 = frec_ini + BW/2 ,  Frec_I2 = Frec_I1 + BW ..... Frec_Fn = Frec_In-1 + BW/2 || if (Frec_Fn == frec_final) = Frec_Fn = Frec_I1

              self.Val_frec = True

              self.frec_inicial = (frec_inicial) + (ancho_banda/2)
              self.frec_final = frec_final
              self.intervalo_tiempo = intervalo_tiempo
              self.intervalo_cambio = ancho_banda
              self.frec_cambio = (frec_inicial) + (ancho_banda/2)

              # Configurar el puerto de mensajes
              self.message_port_register_out(pmt.intern("Frec_out"))

              # Iniciar el hilo del remitente del mensaje
              self.msg_thread = MsgSenderThread(self)
              self.msg_thread.start()



          def send_message(self):

              if self.Val_frec:                      
                  self.frec_cambio = self.frec_inicial
                  self.Val_frec = False

              # Crear el diccionario freq_msg
              freq_msg = {'freq': self.frec_inicial}

              # Enviar freq_msg como un mensaje asincrónico
              msg = pmt.to_pmt(freq_msg)
              self.message_port_pub(pmt.intern("Frec_out"), msg)

              # Calcula el nuevo valor de frecuencia
              self.frec_inicial += self.intervalo_cambio       

              # Si la frecuencia supera el valor final, vuelve a iniciar desde el valor inicial
              if (self.frec_inicial) >= (self.frec_final):
                  self.frec_inicial = self.frec_cambio
                  self.Val_frec = True


          # def send_message(self):

          #     # Crear el diccionario freq_msg
          #     freq_msg = {'freq': self.frec_inicial}

          #     # Enviar freq_msg como un mensaje asincrónico
          #     msg = pmt.to_pmt(freq_msg)
          #     self.message_port_pub(pmt.intern("Frec_out"), msg)

          #     if self.Val_frec:                      
          #         self.frec_cambio = self.frec_inicial
          #         self.Val_frec = False

          #     # Calcula el nuevo valor de frecuencia
          #     self.frec_inicial += self.intervalo_cambio       

          #     # Si la frecuencia supera el valor final, vuelve a iniciar desde el valor inicial
          #     if (self.frec_inicial) >= (self.frec_final):
          #         self.frec_inicial = self.frec_cambio
          #         self.Val_frec = True

          #     # Crear el diccionario freq_msg
          #     freq_msg = {'freq': self.frec_inicial}

          #     # Enviar freq_msg como un mensaje asincrónico
          #     msg = pmt.to_pmt(freq_msg)
          #     self.message_port_pub(pmt.intern("Frec_out"), msg)

          #     return (self.frec_inicial)

          def stop(self):
              self.msg_thread.stop()
              self.msg_thread = None

          def msg_handler(self, msg):
              if pmt.is_eq(msg, pmt.intern("msg_send")):
                  self.send_message()

      class MsgSenderThread(gr.threading.Thread):
          def __init__(self, block):
              gr.threading.Thread.__init__(self)
              self.block = block
              self.running = True

          def stop(self):
              self.running = False

          def run(self):
              while self.running:
                  time.sleep(self.block.intervalo_tiempo)
                  self.block.send_message()
    ancho_banda: samp_rate_0
    frec_final: frec_final
    frec_inicial: frec_inicial
    intervalo_tiempo: '10'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '1024'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(1024)
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_0
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    vlen: '1024'
    x_axis_label: '"Frecuencia MHz"'
    x_start: '0'
    x_step: '1.0'
    y_axis_label: '"dB"'
    ymax: '2'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate_0
    fc: frec_total
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: uhd_usrp_source_1
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: '0'
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '0'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate_0
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_file_sink_0, '0']
- [blocks_nlog10_ff_0, '0', epy_block_0, '0']
- [blocks_nlog10_ff_0, '0', epy_block_2, '0']
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [epy_block_3, Frec_out, blocks_message_debug_0, print]
- [epy_block_3, Frec_out, epy_block_0, Frec_in]
- [epy_block_3, Frec_out, uhd_usrp_source_1, command]
- [fft_vxx_0, '0', blocks_multiply_const_xx_0, '0']
- [uhd_usrp_source_1, '0', blocks_stream_to_vector_0, '0']
- [uhd_usrp_source_1, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_1, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
